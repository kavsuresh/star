Commit message: Update line.xacro

File: model test project 1/line_description/urdf/line.xacro (robot description, xacro)
@@ -74,5 +74,5 @@
   <parent link="base_link"/>
   <child link="Component3_1"/>
-  <axis xyz="0.0 -1.0 0.0"/>
+  <axis xyz="0.0 1.0 0.0"/>
 </joint>
 </robot>
